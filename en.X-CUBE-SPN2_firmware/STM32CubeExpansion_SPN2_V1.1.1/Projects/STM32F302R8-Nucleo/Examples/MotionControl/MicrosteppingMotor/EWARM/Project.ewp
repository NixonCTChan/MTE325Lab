# IAR project Project.ewp, settings and files
configuration X-CUBE-SPN2_F302 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302R8 ST STM32F302R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F302x8
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\..\..\..\Drivers\BSP\Components\L6470; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\STM32F3xx-Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM02A1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM02A1\NUCLEO-F302R8
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\Binary\X-CUBE-SPN2_F302.hex
  postbuild: ielftool.exe --bin --verbose "$CONFIG_NAME$\Exe\$PROJ_FNAME$.out" "..\Binary\X-CUBE-SPN2_F302.bin"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f302x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components/L6470
    ../../../../../../Drivers/BSP/Components/L6470/: L6470.c
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F3xx-Nucleo/: stm32f3xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IHM02A1
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/: xnucleoihm02a1.c
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/NUCLEO-F302R8/: xnucleoihm02a1_interface.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Example/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f302x8.s
  group Example/User
    ../Src/: example.c example_usart.c main.c params.c stm32f3xx_hal_msp.c stm32f3xx_it.c
