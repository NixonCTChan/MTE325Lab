# Keil uVision project Project.uvprojx, settings and files
target STM32F072RB-Nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: X-CUBE-SPN2_F072
  AfterMake: fromelf --bin --output=.\..\Binary\@L.bin !L
  AfterMake: fromelf --i32combined --output=.\..\Binary\@L.hex !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F072xB
  c include: ../Inc;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../Drivers/BSP/Components/L6470;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/STM32F0xx-Nucleo;../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1;../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/NUCLEO-F072RB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Drivers/BSP/Components/L6470
    ../../../../../../Drivers/BSP/Components/L6470/: L6470.c
  group Drivers/BSP/Components/STM32F0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IHM02A1
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/: xnucleoihm02a1.c
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/NUCLEO-F072RB/: xnucleoihm02a1_interface.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f072xb.s
  group Example/User
    ../Src/: example.c example_usart.c main.c params.c stm32f0xx_hal_msp.c stm32f0xx_it.c
software components: CMSIS:CORE 4.3.0
